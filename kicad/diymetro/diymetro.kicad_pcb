# Repository tomarus/diymetro

File README.md:

DIY Metro
=========

An Intellijel Metropolis / Roland System-100 model 185 / Detroit Underground DU-SEQ clone using an Arduino Nano.

This is highly experimental.

* **Don't use the kicad PCB, it's not working**

* [View schematic as pdf](assets/schematic.pdf)

## KiCad design kicad/diymetro/diymetro.kicad_pcb

Parts:
C5, C6: 22p; C_1206_3216Metric
C7, C8, C10, C11, C12, C13: 100n; C_1206_3216Metric
C9: 100uF; GenericCap
J1, J2, J3, J4, J6: AudioJack2_SwitchT; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J5: Conn_02x08_Top_Bottom; IDC-Header_2x08_P2.54mm_Vertical
J7: ICSP; PinHeader_2x03_P2.54mm_Vertical
J8: SER; PinHeader_1x02_P2.54mm_Vertical
J9: OutputSelect; PinHeader_1x03_P2.54mm_Vertical
Q1, Q2: MMBT2222A; SOT23
R1, R47, R48: 100; R_1206_3216Metric
R3, R5: 10K; R_1206_3216Metric
R4, R7: 100K; R_1206_3216Metric
R6: 1M; R_1206_3216Metric
R45: 10k; R_1206_3216Metric
RV1, RV2: R_POT; Potentiometer_Alps_RK09K_Single_Vertical
SW10: SW_Push; SW_PUSH_6mm
U5: ATmega328P-PU; DIP-28_W7.62mm
U6, U7: TL072; SO-8_5.3x6.2mm_P1.27mm
U8: MCP4921-ESN; SOIC-8_3.9x4.9mm_P1.27mm
Y1: Crystal; Crystal_HC49-4H_Vertical

Connections:
+5V: C7.2, C8.2, C9.1, J5.11, J5.12, J7.2, R3.1, R5.1, R6.1, R45.1, RV1.1, RV2.1, U5.7 (VCC), U5.20 (AVCC), U8.1 (VDD), U8.6 (VrefA); also elsewhere on the board
+12V: C10.2, C12.2, J5.9, J5.10, U6.8 (V+), U7.8 (V+)
-12V: C11.2, C13.2, J5.1, J5.2, U6.4 (V-), U7.4 (V-)
/AP_CLK_IN: Q2.3 (C), R5.2, U5.4 (PD2)
/AP_CLK_OUT: U5.13 (PD7), U6.5 (+)
/AP_CV_OUT: J9.2, U7.3 (+)
/AP_GATE_OUT: U5.14 (PB0), U6.3 (+)
/AP_RST_IN: Q1.3 (C), R3.2, U5.5 (PD3)
/CV_POT_OUTPUT: J9.3, U5.27 (PC4); also elsewhere on the board
/ICSP_MISO: J7.1, U5.18 (PB4), U8.2 (~CS~)
/ICSP_MOSI: J7.4, U5.17 (PB3), U8.4 (SDI); also elsewhere on the board
/ICSP_RST: J7.5, R45.2, SW10.1, U5.1 (~RESET~/PC6)
/ICSP_SCK: J7.3, U5.19 (PB5), U8.3 (SCK); also elsewhere on the board
CINSW: J6.TN, R6.2, U5.15 (PB1)
GND: C5.1, C6.1, C7.1, C8.1, C9.2, C10.1, C11.1, C12.1, C13.1, J1.S, J2.S, J3.S, J4.S, J5.3, J5.4, J5.5, J5.6, J5.7, J5.8, J6.S, J7.6, Q1.2 (E), Q2.2 (E), RV1.3, RV2.3, SW10.2, U5.8 (GND), U5.22 (GND), U8.5 (~LDAC~), U8.7 (AVSS); also elsewhere on the board
unnamed: C5.2, U5.10 (XTAL2/PB7), Y1.1
unnamed: C6.2, U5.9 (XTAL1/PB6), Y1.2
unnamed: J1.T, R1.1
unnamed: J2.T, R47.1
unnamed: J3.T, R48.1
unnamed: J4.T, R4.2
unnamed: J6.T, R7.2
unnamed: J8.1, U5.3 (PD1)
unnamed: J8.2, U5.2 (PD0)
unnamed: J9.1, U8.8 (VoutA)
unnamed: Q1.1 (B), R4.1
unnamed: Q2.1 (B), R7.1
unnamed: R1.2, U7.1, U7.2 (-)
unnamed: R47.2, U6.1, U6.2 (-)
unnamed: R48.2, U6.6 (-), U6.7
PIN_CLKPOT: RV2.2, U5.23 (PC0)
PIN_GATEOUT: U5.25 (PC2); also elsewhere on the board
PIN_GATEPOT: RV1.2, U5.24 (PC1)
RA: U5.26 (PC3); also elsewhere on the board
RCLK: U5.16 (PB2); also elsewhere on the board
S0: U5.6 (PD4); also elsewhere on the board
S1: U5.11 (PD5); also elsewhere on the board
S2: U5.12 (PD6); also elsewhere on the board
SA: U5.28 (PC5); also elsewhere on the board

Parts:
C1: 100n; C_1206_3216Metric
R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23: 1K; R_1206_3216Metric
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8: SW_SPDT_MSM; SPDT_Switch_4.72mm
U1: 74HC4051; SOP-16_4.4x10.4mm_P1.27mm

Connections:
+5V: C1.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, U1.16 (VCC); also elsewhere on the board
/Switches/SW0: R8.1, R9.2, SW1.3, U1.13 (A0)
/Switches/SW1: R10.1, R11.2, SW2.3, U1.14 (A1)
/Switches/SW2: R12.1, R13.2, SW3.3, U1.15 (A2)
/Switches/SW3: R14.1, R15.2, SW4.3, U1.12 (A3)
/Switches/SW4: R16.1, R17.2, SW5.3, U1.1 (A4)
/Switches/SW5: R18.1, R19.2, SW6.3, U1.5 (A5)
/Switches/SW6: R20.1, R21.2, SW7.3, U1.2 (A6)
/Switches/SW7: R22.1, R23.2, SW8.3, U1.4 (A7)
GND: C1.1, R9.1, R11.1, R13.1, R15.1, R17.1, R19.1, R21.1, R23.1, U1.6 (~E), U1.7 (VEE), U1.8 (GND); also elsewhere on the board
unnamed: R8.2, SW1.1
unnamed: R10.2, SW2.1
unnamed: R12.2, SW3.1
unnamed: R14.2, SW4.1
unnamed: R16.2, SW5.1
unnamed: R18.2, SW6.1
unnamed: R20.2, SW7.1
unnamed: R22.2, SW8.1
S0: U1.11 (S0); also elsewhere on the board
S1: U1.10 (S1); also elsewhere on the board
S2: U1.9 (S2); also elsewhere on the board
SA: U1.3 (A); also elsewhere on the board

Parts:
C2: 100n; C_1206_3216Metric
D4, D5, D6, D7, D8, D9, D10, D11: LED; LED_D3.0mm
R24, R25, R26, R27, R28, R29, R30, R31: 220; R_1206_3216Metric
U2: 74LS595; SOP-16_4.4x10.4mm_P1.27mm

Connections:
+5V: C2.2, U2.10 (~SRCLR), U2.16 (VCC); also elsewhere on the board
/ICSP_MOSI: U2.14 (SER); also elsewhere on the board
/ICSP_SCK: U2.11 (SRCLK); also elsewhere on the board
GND: C2.1, D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), U2.8 (GND), U2.13 (~OE); also elsewhere on the board
unnamed: D4.2 (A), R24.2
unnamed: D5.2 (A), R25.2
unnamed: D6.2 (A), R26.2
unnamed: D7.2 (A), R27.2
unnamed: D8.2 (A), R28.2
unnamed: D9.2 (A), R29.2
unnamed: D10.2 (A), R30.2
unnamed: D11.2 (A), R31.2
unnamed: R24.1, U2.15 (QA)
unnamed: R25.1, U2.1 (QB)
unnamed: R26.1, U2.2 (QC)
unnamed: R27.1, U2.3 (QD)
unnamed: R28.1, U2.4 (QE)
unnamed: R29.1, U2.5 (QF)
unnamed: R30.1, U2.6 (QG)
unnamed: R31.1, U2.7 (QH)
RCLK: U2.12 (RCLK); also elsewhere on the board

Parts:
R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44: 1K; R_1206_3216Metric
SW9: SW_Rotary12; SR2612F_RotarySwitch

Connections:
+5V: R32.2; also elsewhere on the board
GND: R44.1; also elsewhere on the board
unnamed: R32.1, R33.2, SW9.1
unnamed: R33.1, R34.2, SW9.2
unnamed: R34.1, R35.2, SW9.3
unnamed: R35.1, R36.2, SW9.4
unnamed: R36.1, R37.2, SW9.5
unnamed: R37.1, R38.2, SW9.6
unnamed: R38.1, R39.2, SW9.7
unnamed: R39.1, R40.2, SW9.8
unnamed: R40.1, R41.2, SW9.9
unnamed: R41.1, R42.2, SW9.10
unnamed: R42.1, R43.2, SW9.11
unnamed: R43.1, R44.2, SW9.12
RA: SW9.13; also elsewhere on the board

Parts:
C3: 100n; C_1206_3216Metric
RV3, RV4, RV5, RV6, RV7, RV8, RV9, RV10: R_POT; Potentiometer_Alps_RK09K_Single_Vertical
U3: 74HC4051; SOP-16_4.4x10.4mm_P1.27mm

Connections:
+5V: C3.2, RV3.1, RV4.1, RV5.1, RV6.1, RV7.1, RV8.1, RV9.1, RV10.1, U3.16 (VCC); also elsewhere on the board
/CV Pots/A0: RV3.2, U3.13 (A0)
/CV Pots/A1: RV4.2, U3.14 (A1)
/CV Pots/A2: RV5.2, U3.15 (A2)
/CV Pots/A3: RV6.2, U3.12 (A3)
/CV Pots/A4: RV7.2, U3.1 (A4)
/CV Pots/A5: RV8.2, U3.5 (A5)
/CV Pots/A6: RV9.2, U3.2 (A6)
/CV Pots/A7: RV10.2, U3.4 (A7)
/CV_POT_OUTPUT: U3.3 (A); also elsewhere on the board
GND: C3.1, RV3.3, RV4.3, RV5.3, RV6.3, RV7.3, RV8.3, RV9.3, RV10.3, U3.6 (~E), U3.7 (VEE), U3.8 (GND); also elsewhere on the board
S0: U3.11 (S0); also elsewhere on the board
S1: U3.10 (S1); also elsewhere on the board
S2: U3.9 (S2); also elsewhere on the board

Parts:
C4: 100n; C_1206_3216Metric
RV11, RV12, RV13, RV14, RV15, RV16, RV17, RV18: R_POT; Potentiometer_Alps_RK09K_Single_Vertical
U4: 74HC4051; SOP-16_4.4x10.4mm_P1.27mm

Connections:
+5V: C4.2, RV11.1, RV12.1, RV13.1, RV14.1, RV15.1, RV16.1, RV17.1, RV18.1, U4.16 (VCC); also elsewhere on the board
/Gate Pots/GA0: RV11.2, U4.13 (A0)
/Gate Pots/GA1: RV12.2, U4.14 (A1)
/Gate Pots/GA2: RV13.2, U4.15 (A2)
/Gate Pots/GA3: RV14.2, U4.12 (A3)
/Gate Pots/GA4: RV15.2, U4.1 (A4)
/Gate Pots/GA5: RV16.2, U4.5 (A5)
/Gate Pots/GA6: RV17.2, U4.2 (A6)
/Gate Pots/GA7: RV18.2, U4.4 (A7)
GND: C4.1, RV11.3, RV12.3, RV13.3, RV14.3, RV15.3, RV16.3, RV17.3, RV18.3, U4.6 (~E), U4.7 (VEE), U4.8 (GND); also elsewhere on the board
PIN_GATEOUT: U4.3 (A); also elsewhere on the board
S0: U4.11 (S0); also elsewhere on the board
S1: U4.10 (S1); also elsewhere on the board
S2: U4.9 (S2); also elsewhere on the board

Board: 2 copper layers, 162.8 x 100.0 mm, 115 parts (75 on the bottom side), 99 nets.

## Code that names these connections

File arduino/diymetro/diymetro.ino:

//
// TODO in next PCB version:
// PIN_GATEOUT moved from PIN12/PB4/ICp18 to PIN8/PB0/ICp14
// PIN_CLKINSW moved from A4/PC4/ICp27 to PIN15/PB1/ICp15
// Reversed 595 SER + RCK
// CV Pot Input = A4/PC4/ICp27
//

// Timing configurables, all values are in microseconds.
// You might need to tweak these depending on your hardware.
#define CLOCK_LENGTH 250
#define GATE_DELAY 1000

// Defines the max length in microsecs of the gate length pot.
#define MAX_GATE_TIME 1000000

// sensor inputs
#define PIN_SPEED A1
#define PIN_GATELEN A0
#define PIN_4051_Z A2
#define PIN_MAINSW A3
#define PIN_CLKINSW A4
#define PIN_GATESW A5
#define PIN_CLKIN 2
#define PIN_RSTIN 3

// sensor outputs
#define PIN_CLKOUT 7	 // PD7
#define PIN_GATEOUT 12   // PB4
#define PIN_594_SER 10   // PB2
#define PIN_594_RCLK 11  // PB3
#define PIN_594_SRCLK 13 // PB5

// 4051 port configuration.
// You can't change this without changing PORTD logic below.
#define PIN_4051_S0 4
#define PIN_4051_S1 5
#define PIN_4051_S2 6

void setup()
{
	pinMode(PIN_CLKOUT, OUTPUT);
	pinMode(PIN_GATEOUT, OUTPUT);
	pinMode(PIN_4051_S0, OUTPUT);
	pinMode(PIN_4051_S1, OUTPUT);
	pinMode(PIN_4051_S2, OUTPUT);
	pinMode(PIN_594_SER, OUTPUT);
	pinMode(PIN_594_RCLK, OUTPUT);
	pinMode(PIN_594_SRCLK, OUTPUT);
	pinMode(PIN_CLKIN, INPUT_PULLUP);
	attachInterrupt(digitalPinToInterrupt(PIN_CLKIN), clock_receive, RISING);
	attachInterrupt(digitalPinToInterrupt(PIN_RSTIN), reset_receive, RISING);
	randomSeed(analogRead(0));
	shiftOut2(0x01); // Turn on first led
}

int step = 0;
int stepCount = 0;
int maxSteps = 1;
int reverse = 0;
int substep = 0;

unsigned long lastNotePlayed = micros();
bool gateOpen = false;

// clock_receive is a hardware interrupt callback.
byte clkState = LOW;
volatile byte clock = LOW;
void clock_receive()
{
	clock = !clock;
}

// reset_receive is a hardware interrupt callback.
volatile byte reset = LOW;
void reset_receive()
{
	reset = !reset;
}

// myAnalogRead reads the analog input twice
// to stabilize the ADC input before returning
// a value.
int myAnalogRead(int pin)
{
	analogRead(pin);
	return analogRead(pin);
}

void doreset()
{
	reset = false;
	stepCount = maxSteps;
	step = -1;
	reverse = 0;
	substep = -1;

	lastNotePlayed = micros();
	clkState = LOW;
	clock = HIGH;
}

void loop()
{
	if (reset)
	{
		doreset();
	}
	// gatelen goes from 0.0 to 1.0
	float gatelen = float(myAnalogRead(PIN_GATELEN)) / 1024.0;

	// calc note length in microseconds, this ranges from about 6 to 300 bpm or so
	unsigned long speed = 45000000.0 / (float(myAnalogRead(PIN_SPEED)) + 10.0);

	// clocksw is high if an external clock is plugged in.
	int ic = myAnalogRead(PIN_CLKINSW);
	bool intclock = ic < 512;

	// if the gate is still open, turn it off after some time.
	if (gateOpen && lastNotePlayed < micros() - (MAX_GATE_TIME * gatelen))
	{
		digitalWrite(PIN_GATEOUT, LOW);
		shiftOut2(0);
		gateOpen = false;
	}

	// decide if we want to trigger the next step of the sequencer.
	if (intclock)
	{
		// wait for certain time in internal clock mode
		if (lastNotePlayed > micros() - speed)
		{
			return;
		}
	}
	else
	{
		// wait for clock signal if ext clock is connected
		if (clkState == clock)
		{
			return;
		}
		clkState = clock;
	}

	// always close the gate before sending a new note.
	if (gateOpen)
	{
		digitalWrite(PIN_GATEOUT, LOW);
		shiftOut2(0);
		gateOpen = false;
	}

	lastNotePlayed = micros();
	gateOpen = do_step();
}

// do_step outputs clock + gate and if
// necessary advances the sequencer by a step.
bool do_step()
{
	bool advanced = false;
	stepCount++;
	if (stepCount >= maxSteps)
	{
		stepCount = 0;
		advance();
		advanced = true;
	}

	// Set PIN_4051_Sxx
	PORTD = (PORTD & 0b10001111) | (step << 4);

	// Check the value of the step switch.
	// It's either 0, 511 or 1023 (with some margin).
	int gatesw = myAnalogRead(PIN_GATESW);
	int sw = 0; // default off (middle position)
	if (gatesw > 400 && gatesw < 600)
	{
		sw = 1; // down
	}
	if (gatesw > 900)
	{
		sw = 2; // up
	}

	// Wait for this many microseconds after switching the 4051
	// before sending the gate signal.
	delayMicroseconds(GATE_DELAY);

	// toggle clock and gate if the gate switch is on.
	digitalWrite(PIN_CLKOUT, HIGH);
	bool gate = sw == 1 || (sw == 2 && advanced);
	if (gate)
	{
		digitalWrite(PIN_GATEOUT, HIGH);
		shiftOut2(1 << step);
	}
	// clock time is 10us
	delayMicroseconds(CLOCK_LENGTH);
	digitalWrite(PIN_CLKOUT, LOW);

	maxSteps = map(myAnalogRead(PIN_4051_Z), 0, 1023, 8, 1); // / 128;

	// return whether or not the gate was triggered.
	return gate;
}

// advance the sequencer in forward mode
void advance_fwd(int max)
{
	step++;
	if (step >= max)
	{
		step = 0;
	}
}

// advance the sequencer in pingpong mode
void advance_pingpong()
{
	if (reverse)
	{
		step--;
		if (step < 0)
		{
			step = 7;
			reverse = 0;
			step = 1;
		}
	}
	else
	{
		step++;
		if (step >= 8)
		{
			step = 0;
			reverse = 1;
			step = 6;
		}
	}
}

// advance the sequencer in substep mode
void advance_substep(int len)
{
	substep++;
	if (substep >= len)
	{
		substep = 0;
	}

	if (substep < len - 4)
	{
		// play notes 1-4
		step = substep % 4;
	}
	else
	{
		// play notes 5-8
		step = substep + 8 - len;
	}
}

void advance_random()
{
	step = random(8);
}

byte loop2[] = {0, 1, 2, 3, 4, 0, 1, 2, 3, 5, 0, 1, 2, 3, 6, 0, 1, 2, 3, 7};
void advance_loop2()
{
	substep++;
	if (substep >= 20)
	{
		substep = 0;
	}
	step = loop2[substep];
}

byte rndsteps[8];
int rndstep;
void advance_random_preset_init()
{
	step = random(8);
	rndstep = 0;
	for (int i = 0; i < 8; i++)
	{
		rndsteps[i] = i;
	}
	for (int i = 0; i < 8; i++)
	{
		int x = random(7) + 1;
		byte t = rndsteps[x];
		rndsteps[x] = rndsteps[i];
		rndsteps[i] = t;
	}
}
void advance_random_preset()
{
	rndstep++;
	if (rndstep >= 8)
	{
		rndstep = 0;
	}
	step = rndsteps[rndstep];
}

int lastmainsw = 0;
// advance advances the sequencer by one step
void advance()
{
	int mainsw = map(myAnalogRead(PIN_MAINSW), 0, 1023 - (1023 / 12), 11, 0);
	bool changed = false;

	if (lastmainsw != mainsw)
	{
		lastmainsw = mainsw;
		//    step = 0;
		//    substep = 0;
		changed = true;
	}

	switch (mainsw)
	{
	case 0:
		advance_fwd(4);
		break;
	case 1:
		advance_fwd(6);
		break;
	case 2:
		advance_fwd(8);
		break;
	case 3:
		advance_pingpong();
		break;
	case 4:
		advance_substep(16);
		break;
	case 5:
		advance_substep(24);
		break;
	case 6:
		advance_substep(32);
		break;
	case 7:
		advance_loop2();
		break;
	case 8:
		advance_random();
		break;
	default:
		if (changed)
		{
			advance_random_preset_init();
		}
		advance_random_preset();
		break;
	}
}

// shiftOut writes a byte to the hc594 shift register
// used to control the LEDs.
void shiftOut2(byte data)
{
	digitalWrite(PIN_594_RCLK, LOW);
	shiftOut(PIN_594_SER, PIN_594_SRCLK, MSBFIRST, data);
	digitalWrite(PIN_594_RCLK, HIGH);
}

## Commit log

2018-12-31 Initial Commit.
2019-01-02 Update schematic a bit.
2019-01-02 Make note about the PCB
2019-01-02 Try a nicer youtube link.
2019-02-01 Work on clock input.
2019-02-02 Update code for clock input, auto format code, add some comments.
2019-02-02 Cleanup a bit.
2019-02-10 Update code and schematics for clock and reset input.
2019-02-20 Add 200μs delay before sending clock + gate signals.
2019-03-09 Fix the 4051 port selection and gate offset delay.
2019-04-28 Add Ryk 185 split mode support.
2019-09-07 Commit latest running version.
2019-09-07 New schematics and boards.
2019-09-07 Add openscad panel file.
2019-09-17 Add mains cap, Reduce font size.
2019-09-17 Add gerbers as used for board version 1.0.
2019-09-20 Update code for 1.0 boards.
2019-09-20 Fix max steps in random mode.
2019-09-20 Fix 74hc595 OE pin, Fix MBT2222A symbol + footprint, Fix clock-in jack connections.
2019-09-20 Add missing C9
2019-09-20 Add missing footprint for C9
2019-09-20 Update footprints for switches.
2019-09-20 Remove some unused diodes.
2019-09-20 Swap CV pots GND vs 5V
2019-09-20 Change GND/5V on gate pots too, Optimize a lot of traces and vias.
2019-09-20 Optimize some more traces.
2019-09-21 Add TL072 output buffers for gate/clock/cv outputs.
2019-09-21 Move gate output pin from pin12/PB4 to pin8/PB0.
2019-09-22 Add new playmode.
2019-09-23 Move around some stuff.
2019-09-28 Remove some debug/test stuff.
